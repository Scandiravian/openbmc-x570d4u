PACKAGECONFIG:remove = " intelcpusensor"
